# Keil uVision project freertos_blinky.uvproj, settings and files
target iflash_nxp_lpcxpresso_1549 (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1549 NXP (founded by Philips)
  cpu: IRAM(0x02000000-0x02008FFF) IROM(0x0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: freertos_blinky
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: .\lpc_core\lpc_board\boards_15xx\nxp_lpcxpresso_1549;.\lpc_core\lpc_chip\chip_common;.\lpc_core\lpc_chip\chip_15xx;.\lpc_core\lpc_chip\chip_15xx\config_15xx;.\CMSIS;.\lpc_core\lpc_board\board_common;.\freertos\freertos\Source\include;.\freertos\freertos\Source\portable\RVDS\ARM_CM3;.\examples\freertos\freertos_blinky;.\keil_output
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x9000
  group example
    ./startup_code/: sysinit.c
    ./examples/freertos/freertos_blinky/: freertos_blinky.c
    ./examples/freertos/startup_code/: keil_freertos_startup_lpc15xx.s
  group lib
    ./lpc_core/lpc_chip/chip_15xx/keil_output/chip_15xx_lib/: chip_15xx_lib.lib
    ./keil_output/: board_nxp_lpcxpresso_1549.lib
  group freertos
    ./freertos/freertos/Source/: list.c queue.c tasks.c timers.c
    ./freertos/freertos/Source/portable/MemMang/: heap_3.c
    ./freertos/freertos/Source/portable/RVDS/ARM_CM3/: port.c
    ./freertos/freertoslpc/: FreeRTOSCommonHooks.c
  group src
    ./: main.c
