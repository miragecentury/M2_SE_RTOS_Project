# Keil uVision project lib_lpc_board_nxp_lpcxpresso_1549.uvproj, settings and files
target nxp_lpcxpresso_1549 (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1549 NXP (founded by Philips)
  cpu: IRAM(0x02000000-0x02008FFF) IROM(0x0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: board_nxp_lpcxpresso_1549 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\CMSIS;..\..\..\lpc_chip\chip_15xx;..\..\..\lpc_chip\chip_15xx\config_15xx;..\..\..\lpc_chip\chip_common;..\nxp_lpcxpresso_1549;..\..\board_common
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x9000
  group board_nxp_lpcxpresso_1549
    ./: board.c board_sysinit.c
